EXTRA_OECONF += "--disable-api-docs"
